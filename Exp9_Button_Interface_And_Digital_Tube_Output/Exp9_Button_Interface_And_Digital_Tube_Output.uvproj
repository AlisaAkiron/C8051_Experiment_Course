# Keil uVision project Exp9_Button_Interface_And_Digital_Tube_Output.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Exp9_Button_Interface_And_Digital_Tube_Output +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exp9_Button_Interface_And_Digital_Tube_Output.c ZLG7289.c
