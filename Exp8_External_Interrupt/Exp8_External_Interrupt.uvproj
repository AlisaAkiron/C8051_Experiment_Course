# Keil uVision project Exp8_External_Interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Exp8_External_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exp8_External_Interrupt.c c8051F020.h
